# Keil uVision project uMod.uvproj, settings and files
target Project (MCS-51)
  device: CMS80F262x Cmsemicon
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM(0x0000-0x0FFF) CLOCK(24000000) MODDP2
  output: uMod +hex
  AfterMake: python Scripts\umod_patcher.py -i Resources\base_fw.bin -o Objects\uMod.bin --hexfile Objects\uMod.hex --mapfile Listings\uMod.map
  c flags: Optimize=9 SizeSpeed=1
  c include: .\Code\Device;.\Code\User
  group User
    ./Code/User/: colors.h firmware.c firmware.h firmware_offsets.h main.c umod.c umod.h hooks.a51 libcode.a51 menu.c menu.h smeter.h bool.h _fntcave.c _tstcave.c
  group MCU
    ./Code/Device/: STARTUP.A51 ta3782f.h
